# Keil uVision project QuadCopter.uvprojx, settings and files
target QuadCopter (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: text +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD,KEIL_PROJECT,__ppc__,QUAD_FORMATION_X
  c include: ..\USER;..\STM32F10x_StdPeriph_Driver\inc;..\CM3\CoreSupport;..\CM3\DeviceSupport\STM32F10x;..\CM3\DeviceSupport\STM32F10x\startup\arm;..\FreeRTOS\Source\include;..\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\Drivers\inc;..\Hardware\inc;..\Application\inc;..\Configure;..\Utils\inc;..\Modules\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./: main.c stm32f10x_it.c
  group Application
    ../Application/src/: radiolink.c crtp.c ledseq.c comm.c console.c system.c imu.c pm.c
  group Modules
    ../Modules/src/: pid.c pidctrl.c controller.c commander.c sensfusion6.c worker.c
  group Utils
    ../Utils/src/: cfassert.c eprintf.c filter.c fp16.c
    ../Modules/src/: stabilizer.c
  group Hardware
    ../Hardware/src/: nRF24L01.c motors.c mpu6050.c hmc5883l.c ms5611.c
  group Drivers
    ../Drivers/src/: stm32_qdcpt.c Stm32Print.c stm32_qdcpt_usart.c stm32_qdcpt_led.c stm32_qdcpt_exti.c stm32_qdcpt_i2c.c stm32_qdcpt_i2c_routines.c stm32_qdcpt_adc.c
  group Configure
    ../Configure/: nvic_configure.h FreeRTOSConfig.h stm32f10x_conf.h errno.h
  group FreeRTOS
    ../FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/Source/: croutine.c list.c queue.c tasks.c timers.c
  group Std_Lib
    ../STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../CM3/CoreSupport/: core_cm3.c
    ../CM3/DeviceSupport/STM32F10x/: system_stm32f10x.c
    ../CM3/DeviceSupport/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group Doc
    ./: readme.txt
